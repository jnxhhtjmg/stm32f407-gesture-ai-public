# Keil uVision project f407_gesture_ai.uvprojx, settings and files
target f407_gesture_ai (6070000::V6.7::.\ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: f407_gesture_ai +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,TF_LITE_STRIP_ERROR_STRINGS
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../third_party/tflite-micro;../third_party/tflite-micro/third_party/flatbuffers/include
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c i2c.c mpu6050.c gesture_preprocess.c gesture_event.c gesture_proto.c oled_ssd1306.c tim.c usart.c uart_tx.c stm32f4xx_it.c stm32f4xx_hal_timebase_tim7.c stm32f4xx_hal_msp.c g_gesture_model_data.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group LiteRT Micro
    ../Core/Src/: gesture_inference.cc debug_log_uart.cc
    ../third_party/tflite-micro/tensorflow/lite/micro/: flatbuffer_conversions.cc flatbuffer_utils.cc hexdump.cc memory_helpers.cc micro_allocation_info.cc micro_allocator.cc micro_common.cc micro_context.cc micro_interpreter_context.cc micro_interpreter_graph.cc micro_interpreter.cc micro_log.cc micro_op_resolver.cc micro_profiler.cc micro_resource_variable.cc micro_time.cc micro_utils.cc recording_micro_allocator.cc system_setup.cc
    ../third_party/tflite-micro/tensorflow/lite/micro/kernels/internal/: common.cc portable_tensor_utils.cc quantization_util.cc runtime_shape.cc tensor_ctypes.cc
    ../third_party/tflite-micro/tensorflow/lite/micro/kernels/: add.cc add_common.cc conv.cc conv_common.cc expand_dims.cc fully_connected.cc fully_connected_common.cc mul.cc mul_common.cc pooling.cc pooling_common.cc reduce.cc reduce_common.cc reshape.cc reshape_common.cc pack.cc shape.cc strided_slice.cc strided_slice_common.cc softmax.cc softmax_common.cc kernel_util.cc
    ../third_party/tflite-micro/tensorflow/lite/micro/arena_allocator/: non_persistent_arena_buffer_allocator.cc persistent_arena_buffer_allocator.cc recording_single_arena_buffer_allocator.cc single_arena_buffer_allocator.cc
    ../third_party/tflite-micro/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cc linear_memory_planner.cc non_persistent_buffer_planner_shim.cc
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.0.1
